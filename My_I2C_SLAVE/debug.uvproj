# Keil uVision project debug.uvproj, settings and files
target Target 1 (MCS-51)
  device: ADuC847 Analog Devices
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0xF7FF) CLOCK(32768) DPX MODAB2
  output: debug +hex
  c flags: SizeSpeed=1
  group Source Group 1
    ./: debug.c preferences.h watchdog.c START_AD.A51 dol.c i2c_slave.c frequency.c channels.c
