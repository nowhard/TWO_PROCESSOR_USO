# Keil uVision project debug.uvproj, settings and files
target Target 1 (MCS-51)
  device: ADuC847 Analog Devices
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0xF7FF) CLOCK(32768) DPX MODAB2
  output: debug +hex
  c flags: SizeSpeed=1
  group Source Group 1
    ./: debug.c timer3.c adc.c preferences.h watchdog.c START_AD.A51 frequency.c timer0.c timer2.c i2c.c ulongsort.c timer1.c
    ./eeprom/: eeprom.c
    ./proto_uso/: proto_uso.c channels.c
    ./calibrate/: calibrate.c
    ./pt/: pt.h lc.h lc-switch.h
